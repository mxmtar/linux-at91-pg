## drivers/polygator/Kconfig
```kconfig
menuconfig POLYGATOR
	bool "Polygator Devices Support"
	help
	  G20 Polygator devices support.

	  If unsure, say no.
```
